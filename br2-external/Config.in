## br2-external/package/edge-agent/Config.in
```kconfig
config BR2_PACKAGE_EDGE_AGENT
	bool "edge-agent"
	help
	  Minimal user-space agent used by the lab series.
```
